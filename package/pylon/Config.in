## package/pylon/Config.in
```kconfig
config BR2_PACKAGE_PYLON
	bool "pylon"
	depends on BR2_aarch64
	depends on BR2_INSTALL_LIBSTDCPP
	help
	  Basler Pylon C++ SDK for machine vision cameras.
```
